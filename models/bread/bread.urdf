Commit message: Try to add color to the bread.

File: models/bread/bread.urdf (robot description, URDF)
Before this commit: robot bread, 1 links, 0 joints
Links:
- link bread: geometry collision box size=0.0001 0.0001 0.0001; visual mesh filename=package://pizza_demo/models/bread/meshes/bread.dae
