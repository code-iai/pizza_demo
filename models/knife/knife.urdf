Commit message: Trying to add color to objects.

File: models/knife/knife.urdf (robot description, URDF)
Before this commit: robot knife, 1 links, 0 joints
Links:
- link knife: geometry collision box size=0.0001 0.0001 0.0001; visual mesh filename=package://pizza_demo/models/knife/meshes/knife.dae
